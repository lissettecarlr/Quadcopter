# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\lib;..\usr;..\lib\math;..\lib\offchip\HMC5883L;..\lib\offchip\HMI;..\lib\offchip\MPU6050;..\lib\offchip\Sensor;..\lib\offchip\UranusIMU;..\lib\onchip\ADC;..\lib\onchip\flash;..\lib\onchip\GPIO;..\lib\onchip\I2C;..\lib\onchip\interrupt;..\lib\onchip\PWM;..\lib\onchip\taskManager;..\lib\onchip\timer;..\lib\onchip\USART;..\lib\onchip\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../lib/onchip/ADC/: ADC.cpp
    ../lib/onchip/flash/: Flash.cpp
    ../lib/onchip/GPIO/: GPIO.cpp
    ../lib/onchip/I2C/: I2C.cpp
    ../lib/onchip/interrupt/: Interrupt.cpp
    ../lib/onchip/PWM/: PWM.cpp
    ../lib/onchip/taskManager/: TaskManager.cpp
    ../lib/onchip/timer/: Timer.cpp
    ../lib/onchip/USART/: USART.cpp
    ../lib/onchip/delay/: Delay.cpp
  group usr
    ../usr/: main.cpp UserInterrupt.cpp Configuration.h
    ../lib/offchip/UranusIMU/: UranusIMU.cpp
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
